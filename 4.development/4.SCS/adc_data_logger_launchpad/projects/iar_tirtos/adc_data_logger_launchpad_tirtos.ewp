# IAR project adc_data_logger_launchpad_tirtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1350F128 TexasInstruments CC1350F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC13XXWARE; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg/compiler.opt.defs
  ICCARM.CCIncludePath2: C:\ti\tirtos_cc13xx_cc26xx_2_21_00_06\products\cc13xxware_2_04_03_17272; C:\ti\tirtos_cc13xx_cc26xx_2_21_00_06\packages; C:\ti\tirtos_cc13xx_cc26xx_2_21_00_06\products\tidrivers_cc13xx_cc26xx_2_21_00_04\packages\ti\boards\CC1350_LAUNCHXL; C:\ti\tirtos_cc13xx_cc26xx_2_21_00_06\products\tidrivers_cc13xx_cc26xx_2_21_00_04\packages
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc_data_logger_launchpad_tirtos.srec
  prebuild: "C:\ti\xdctools_3_32_00_06_core\xs" --xdcpath="C:\ti\tirtos_cc13xx_cc26xx_2_21_00_06\products\bios_6_46_01_37\packages;C:\ti\tirtos_cc13xx_cc26xx_2_21_00_06\products\tidrivers_cc13xx_cc26xx_2_21_00_04\packages" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: adc_data_logger_launchpad_tirtos.out
  ILINK.IlinkConfigDefines: RTOS_ROM=1
  ILINK.IlinkIcfFile: C:\ti\tirtos_cc13xx_cc26xx_2_21_00_06\products\cc13xxware_2_04_03_17272\linker_files\cc13x0f128.icf
  ILINK.IlinkExtraOptions: -f configPkg/linker.cmd
  ILINK.IlinkAdditionalLibs: C:\ti\tirtos_cc13xx_cc26xx_2_21_00_06\products\cc13xxware_2_04_03_17272\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: rom.cfg
    ../../source/: scif.c scif.h scif_framework.c scif_framework.h scif_osal_tirtos.h main_tirtos.c
  group sdk_files__do_not_edit
    C:/ti/tirtos_cc13xx_cc26xx_2_21_00_06/products/tidrivers_cc13xx_cc26xx_2_21_00_04/packages/ti/boards/CC1350_LAUNCHXL/: CC1350_LAUNCHXL.c Board.h
    C:/ti/tirtos_cc13xx_cc26xx_2_21_00_06/products/cc13xxware_2_04_03_17272/startup_files/: ccfg.c
